# Keil uVision project STM32_Demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT
  c include: ..\Code;..\Code\APP;..\Code\BSP;..\Code\BSP\SYSTEM;..\Code\BSP\SYSTEM\delay;..\Code\BSP\SYSTEM\sys;..\Code\BSP\SYSTEM\usart;..\Code\STLIB;..\Code\STLIB\CMSIS;..\Code\STLIB\CMSIS\CORE;..\Code\STLIB\DSPLIB\Include;..\Code\STLIB\FWLIB\inc;..\Code\uCOSIII;..\Code\uCOSIII\uCOS_CPU;..\Code\uCOSIII\uCOS_LIB;..\Code\uCOSIII\uCOS_III;..\Code\uCOSIII\uCOS_III\Source;..\Code\uCOSIII\uCOS_BSP;..\Code\uCOSIII\uCOS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../Code/APP/Math/: My_Math.c
    ../Code/APP/ANO_DT/: ANO_DT.c
    ../Code/APP/Task_Loop/: Task_Loop.c
    ../Code/APP/Display/: Display.c
    ../Code/APP/Sensor_Param/: Sensor_Param.c
    ../Code/APP/IMU/: IMU.c
  group BSP
    ../Code/BSP/SYSTEM/sys/: sys.c
    ../Code/BSP/SYSTEM/usart/: Printf_Uart.c
    ../Code/BSP/: My_BSP.c
    ../Code/BSP/BEEP/: BEEP.c
    ../Code/BSP/LED/: LED.c
    ../Code/BSP/MCU/SysTick/: SysTick.c
    ../Code/BSP/Time/: Time.c
    ../Code/BSP/MCU/FLASH/: stmflash.c
    ../Code/BSP/OLED/: OLED.c
    ../Code/BSP/MCU/IIC_Soft/: IIC_Soft.c
    ../Code/BSP/MPU6050/: MPU6050.c
    ../Code/BSP/AK8975/: AK8975.c
    ../Code/BSP/Encoder/: Encoder.c
    ../Code/BSP/KEY/: KEY.c
    ../../../NUEDC_2017/NUEDC_2017/Code/BSP/Motor_Drive/: Moto_Drive.c
  group STLIB
    ../Code/STLIB/CMSIS/STARTUP/: startup_stm32f40_41xxx.S
    ../Code/STLIB/CMSIS/: system_stm32f4xx.c
    ../Code/STLIB/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Code/STLIB/: stm32f4xx_it.c
  group USER
    ../Code/: main.c
